# IAR project FlashTCASxxx.ewp, settings and files
configuration FlashTC60xx (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: DIE_TC6001
  ICCARM.CCIncludePath2: inc; $TOOLKIT_DIR$\src\flashloader\framework2; ..\..; ..\..\..\..\..\driver\inc; ..\..\..\..\..\device\common\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashTCASxxx.srec
  ILINK.IlinkOutputFile: FlashTCASxxx.out
  ILINK.IlinkIcfFile: FlashTCASxxxRAM8K.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashTCASxxx.c
  group framework
    ../framework2/: flash_loader.c flash_loader_asm.s

# IAR project Oximeter_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TCASxxx TINYCHIP TCASxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\common\inc; ..\driver\inc; ..\midware\inc; ..\Users\Algorithm; ..\Users\BlueToothDrivers; ..\Users\BuzzDrivers; ..\Users\FuncDrivers; ..\Users\OledDrivers; ..\Users; ..\midware\RTT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Oximeter_example.srec
  ILINK.IlinkOutputFile: Oximeter_example.out
  ILINK.IlinkIcfFile: Oximeter_example.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BLH_Drivers
    ../Users/BlueToothDrivers/: BluetoothDriver.c
  group BuzzDrive
    ../Users/BuzzDrivers/: BuzzDriver.c
  group common
    ../common/src/: startup_tcasxxx_iar.s system_tcasxxx.c
  group FuncDrivers
    ../Users/FuncDrivers/: DefaultSetup.c LightDriver.c Preprocess.c
    ../Users/Algorithm/: Spo2Interface.c
  group MainFunction
    ../Users/: main.c SystemDriver.c
  group MCUdriver
    ../driver/src/: aes.c ana_misc.c cmp.c delay.c divider.c dma.c flash.c gpio.c i2c.c idac.c interrupt.c lpm.c lvd.c op.c rtc.c saradc.c spi.c tia.c timer.c trim.c uart.c vdac.c wdg.c
  group Midware
    ../midware/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
    ../midware/src/: trace.c
  group OledDrivers
    ../Users/OledDrivers/: DisplayDriver.c fontlibs.c UG2864Driver.c

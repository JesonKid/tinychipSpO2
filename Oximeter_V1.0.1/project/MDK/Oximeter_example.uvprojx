# Keil uVision project Oximeter_example.uvprojx, settings and files
target Oximeter_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TCASxxx TinyChip
  pack: Keil.TCASxxx.1.1.6
  cpu: IRAM(0x00004000,0x2000) IROM(0x00004000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Oximeter_example +hex
  AfterMake: fromelf --bin --output=./Objects/@L.bin !L
  AfterMake: fromelf -c ./Objects/@L.axf -o ./Objects/@L.txt
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: FUNC_RESP, FUNC_DIAGNOSE
  c include: ..\common\inc;..\driver\inc;..\midware\inc;..\Users;..\Users\Algorithm;..\Users\FuncDrivers;..\Users\BlueToothDrivers;..\Users\BuzzDrivers;..\Users\OledDrivers;..\midware\RTT;..\Users\SegDrivers;..\midware\pt-1.4\pt-1.4
  library: MicroLIB
  memory RVCT9: RAM 0x4000 size 0x2000
  scatter file: .\Scripts\oximeter_example.sct
  link misc: --entry Reset_Handler
  group MainFunction
    ../Users/: SystemDriver.c main.c
  group MCUdriver
    ../driver/src/: gpio.c delay.c dma.c uart.c i2c.c vdac.c op.c tia.c saradc.c aes.c cmp.c timer.c divider.c flash.c idac.c interrupt.c lpm.c lvd.c rtc.c spi.c trim.c wdg.c
  group common
    ../common/src/: startup_tcasxxx.s system_tcasxxx.c
  group FuncDrivers
    ../Users/FuncDrivers/: DefaultSetup.c LightDriver.c Preprocess.c
    ../Users/Algorithm/: Spo2Interface.c
  group OledDrivers
    ../Users/OledDrivers/: DisplayDriver.c fontlibs.c UG2864Driver.c
  group BLH_Drivers
    ../Users/BlueToothDrivers/: BluetoothDriver.c
  group BuzzDrive
    ../Users/BuzzDrivers/: BuzzDriver.c
  group Midware
    ../midware/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
    ../midware/src/: trace.c
  group SegDrivers
    ../Users/SegDrivers/: SegDriver.c
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDOUT 1.2.0
